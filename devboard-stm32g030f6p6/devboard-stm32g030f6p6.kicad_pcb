# Repository Finomnis/GenericHardware

File README.md:

# GenericHardware
Generic Hardware Projects that didn't fit in anywhere else and were too small to get their own repository.

## KiCad design devboard-stm32g030f6p6/devboard-stm32g030f6p6.kicad_pcb

Parts:
C1, C7: 100n; C_0603_1608Metric
C2, C3: 1u; C_0603_1608Metric
C4: 4.7u; C_0603_1608Metric
C5, C6: 10p; C_0402_1005Metric
D1: User; LED_0805_2012Metric
D2: Power; LED_0805_2012Metric
FB1, FB2: 100; L_0805_2012Metric
J1: USB_B_Micro; SHOUHAN_MICROXNJ
J2: Conn_ARM_JTAG_SWD_10; PinHeader_2x05_P1.27mm_Vertical_SMD
J3: Pins_Right; PinHeader_1x08_P2.54mm_Vertical
J4: Pins_Left; PinHeader_1x07_P2.54mm_Vertical
R1, R2: 10k; R_0603_1608Metric
R3: 330; R_0603_1608Metric
R4: 330; R_0402_1005Metric
SW1: Reset; button_ts_1092s_b3d2_g
U1: STM32G030F6P6; STMicroelectronics-TSSOP20-YA-0-3-IPC_B; mouser part number 511-STM32G030F6P6; digikey description ARM MICROCONTROLLERS - MCU
U2: XC6206P332MR; SOT-23
Y1: 32MHz; osc_ssd_7F32000E12UCG; Part 7F32000E12UCG

Connections:
+3V3: C3.1, C4.1, C7.1, J2.1 (VTref), J4.2, R2.1, U1.4 (VDD/VDDA), U2.2 (VO)
+5V: FB1.2, J4.1
A0: J3.1, U1.7 (PA0)
A1: J3.2, U1.8 (PA1)
A2: J3.3, U1.9 (PA2)
A3: J3.4, U1.10 (PA3)
A4: J3.5, U1.11 (PA4)
A5: J3.6, U1.12 (PA5)
A6: J3.7, U1.13 (PA6)
A7: J3.8, U1.14 (PA7)
GND: C1.2, C2.2, C3.2, C4.2, C5.1, C6.2, C7.2, D1.1 (K), D2.1 (K), J1.5 (GND), J2.3 (GND), J2.5 (GND), J2.9 (GNDDetect), J4.3, SW1.2, U1.5 (VSS/VSSA), U2.1 (GND), Y1.2, Y1.4
I2C_SCL: J4.7, U1.16 (PA11[PA9])
I2C_SDA: J4.6, U1.17 (PA12[PA10])
LED_USER: R1.1, U1.15 (PB0/PB1/PB2/PA8)
NRESET: J2.10 (~RESET~), R3.1, U1.6 (~RST~)
unnamed: C1.1, R3.2, SW1.1
unnamed: C2.1, FB2.2, U2.3 (VI)
unnamed: C5.2, U1.2 (PB9/PC14-OSC32_IN), Y1.1
unnamed: C6.1, R4.2, Y1.3
unnamed: D1.2 (A), R1.2
unnamed: D2.2 (A), R2.2
unnamed: FB1.1, FB2.1, J1.1 (VBUS)
unnamed: R4.1, U1.3 (PC15-OSC32_OUT)
SWDCLK: J2.4 (SWDCLK/TCK), U1.19 (PA15/PA14-BOOT0)
SWDIO: J2.2 (SWDIO/TMS), U1.18 (PA13)
UART_RX: J4.4, U1.1 (PB7/PB8)
UART_TX: J4.5, U1.20 (PB3/PB4/PB5/PB6)

Board: 4 copper layers, 17.8 x 26.7 mm, 23 parts (2 on the bottom side), 27 nets.

## Commit log

2021-11-11 Add stm32g030f6p6 devboard
2021-11-11 Fix shield connections for USB footprint
2021-11-11 Fix USB shielding, again
2021-11-11 Add board layout
2021-11-11 More layout work
2021-11-11 Finish layout
2021-11-12 Fix usb not being marked SMD
2021-11-12 Add release files
2021-11-12 Final version, sent to JLCPCB
2021-11-26 Add firmware hello world
2021-11-26 Remove licenses from firmware folder
2021-11-26 Add schematic pdf
2021-11-27 Added blinky example
2022-01-21 Fix oscillator being rotated by 90 degrees
2022-01-21 Reduce crystal bypass capacitors to 10p, frequency measures too low
2022-01-21 Update 10p caps in pcb
2022-01-21 Increase via size to 0.25mm
2022-01-21 Increase crystal bypass caps back up to 12p
2023-05-10 Update to newer library versions
